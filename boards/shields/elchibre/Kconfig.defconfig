## boards/shields/elchibre/Kconfig.defconfig
```kconfig
if SHIELD_ELCHIBRE

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "El Chibre"

endif
```
